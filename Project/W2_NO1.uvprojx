# Keil uVision project W2_NO1.uvprojx, settings and files
target W2_NO1_103 (5060960::V5.06 update 7 (build 960)::.\ARM_Compile_5.06)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W2_NO1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS\Include;..\CMSIS\Device\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\main;..\User\app;..\User\config;..\User\tuya;..\User\driver;..\User\system;..\User\MQTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../User/main/: main.c main_timer.c key.c key_task.c event.c event_task.c mode.c mode_task.c mqtt_msg.c device.c type_def.h
  group App
    ../User/app/: datetime.c sensor.c
  group MQTT
    ../User/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Tuya
    ../User/tuya/: mcu_api.c protocol.c system.c tuya_wifi_usart.c wifi.h
  group Driver
    ../User/driver/: buzzer.c sensor_DHT11.c sensor_DHT20.c sensor_JW01.c wifi_buffer.c wifi_LPC330.c
  group Config
    ../User/config/: config.h config_030.c config_103.c timer_main.c device_gpio.c key_gpio.c DHT11_swp.c DHT20_i2c.c JW01_usart.c wifi_usart.c usart.c
  group System
    ../User/system/: delay.c sys.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_misc.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/Device/Source/: system_stm32f10x.c
  group Startup
    ../CMSIS/Device/Source/arm/: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.6.0
